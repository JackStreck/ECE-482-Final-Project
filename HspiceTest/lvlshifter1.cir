* =======================================================
* Level Shifter 1.1 V -> 1.8 V  FUNCTIONALITY TEST
* Using extracted devices from layout
* =======================================================

***** MODELS ************************************************
.lib '/class/ece482/gpdk045_mos' TT

.TEMP 25
.OPTION POST             ; generate .tr0

***** SUPPLIES **********************************************
* High-voltage domain (IO)
VDD   vdd   0   1.8
* Ground
VSS   vss   0   0

***** INPUT SOURCES (core domain, 0–1.1 V) *****************
* b_core: 0 -> 1.1 V -> 0 ...
VBCORE     b_core      0   PULSE(0 1.1 0 20p 20p 5n 10n)
* b_core_bar: complement of b_core
VBCOREBAR  b_core_bar  0   PULSE(1.1 0 0 20p 20p 5n 10n)

***** LEVEL SHIFTER DEVICES (EXTRACTED) ********************
** Library name: test2
** Cell name: level_shifter_1_1_to_1_8
** View name: schematic

m1 bio b_core_bar vss vss g45n2svt L=150e-9 W=320e-9 AD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:(floor(ceil(31.9995e-3)/2.0)*(200e-9*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?150e-9*(320e-9/ceil(31.9995e-3)):0))/1' AS='320e-9/ceil(31.9995e-3)<119.5e-9?(((14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9)+floor((ceil(31.9995e-3)-1)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:((150e-9*(320e-9/ceil(31.9995e-3))+floor((ceil(31.9995e-3)-1)/2.0)*(200e-9*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?150e-9*(320e-9/ceil(31.9995e-3)):0))/1'
+PD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*680e-9+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?580e-9:0))/1:(floor(ceil(31.9995e-3)/2.0)*(400e-9+2*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?300e-9+2*(320e-9/ceil(31.9995e-3)):0))/1' PS='320e-9/ceil(31.9995e-3)<119.5e-9?((580e-9+floor((ceil(31.9995e-3)-1)/2.0)*680e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?580e-9:0))/1:(((300e-9+2*(320e-9/ceil(31.9995e-3)))+floor((ceil(31.9995e-3)-1)/2.0)*(400e-9+2*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?300e-9+2*(320e-9/ceil(31.9995e-3)):0))/1'
+NRD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:((floor(ceil(31.9995e-3)/2.0)*(200e-9*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?150e-9*(320e-9/ceil(31.9995e-3)):0))/1)/((((320e-9/ceil(31.9995e-3))*ceil(31.9995e-3))*(320e-9/ceil(31.9995e-3)))*ceil(31.9995e-3))' NRS='320e-9/ceil(31.9995e-3)<119.5e-9?(((14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9)+floor((ceil(31.9995e-3)-1)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:(((150e-9*(320e-9/ceil(31.9995e-3))+floor((ceil(31.9995e-3)-1)/2.0)*(200e-9*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?150e-9*(320e-9/ceil(31.9995e-3)):0))/1)/((((320e-9/ceil(31.9995e-3))*ceil(31.9995e-3))*(320e-9/ceil(31.9995e-3)))*ceil(31.9995e-3))' M=1

m0 bio_bar b_core vss vss g45n2svt L=150e-9 W=320e-9 AD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:(floor(ceil(31.9995e-3)/2.0)*(200e-9*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?150e-9*(320e-9/ceil(31.9995e-3)):0))/1' AS='320e-9/ceil(31.9995e-3)<119.5e-9?(((14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9)+floor((ceil(31.9995e-3)-1)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:((150e-9*(320e-9/ceil(31.9995e-3))+floor((ceil(31.9995e-3)-1)/2.0)*(200e-9*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?150e-9*(320e-9/ceil(31.9995e-3)):0))/1'
+PD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*680e-9+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?580e-9:0))/1:(floor(ceil(31.9995e-3)/2.0)*(400e-9+2*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?300e-9+2*(320e-9/ceil(31.9995e-3)):0))/1' PS='320e-9/ceil(31.9995e-3)<119.5e-9?((580e-9+floor((ceil(31.9995e-3)-1)/2.0)*680e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?580e-9:0))/1:(((300e-9+2*(320e-9/ceil(31.9995e-3)))+floor((ceil(31.9995e-3)-1)/2.0)*(400e-9+2*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?300e-9+2*(320e-9/ceil(31.9995e-3)):0))/1'
+NRD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:((floor(ceil(31.9995e-3)/2.0)*(200e-9*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?150e-9*(320e-9/ceil(31.9995e-3)):0))/1)/((((320e-9/ceil(31.9995e-3))*ceil(31.9995e-3))*(320e-9/ceil(31.9995e-3)))*ceil(31.9995e-3))' NRS='320e-9/ceil(31.9995e-3)<119.5e-9?(((14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9)+floor((ceil(31.9995e-3)-1)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:(((150e-9*(320e-9/ceil(31.9995e-3))+floor((ceil(31.9995e-3)-1)/2.0)*(200e-9*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?150e-9*(320e-9/ceil(31.9995e-3)):0))/1)/((((320e-9/ceil(31.9995e-3))*ceil(31.9995e-3))*(320e-9/ceil(31.9995e-3)))*ceil(31.9995e-3))' M=1

mpm1 bio bio_bar vdd vdd g45p2svt L=150e-9 W=320e-9 AD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:(floor(ceil(31.9995e-3)/2.0)*(110e-9*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?140e-9*(320e-9/ceil(31.9995e-3)):0))/1' AS='320e-9/ceil(31.9995e-3)<119.5e-9?(((14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9)+floor((ceil(31.9995e-3)-1)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:((140e-9*(320e-9/ceil(31.9995e-3))+floor((ceil(31.9995e-3)-1)/2.0)*(110e-9*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?140e-9*(320e-9/ceil(31.9995e-3)):0))/1'
+PD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*680e-9+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?580e-9:0))/1:(floor(ceil(31.9995e-3)/2.0)*(220e-9+2*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?280e-9+2*(320e-9/ceil(31.9995e-3)):0))/1' PS='320e-9/ceil(31.9995e-3)<119.5e-9?((580e-9+floor((ceil(31.9995e-3)-1)/2.0)*680e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?580e-9:0))/1:(((280e-9+2*(320e-9/ceil(31.9995e-3)))+floor((ceil(31.9995e-3)-1)/2.0)*(220e-9+2*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?280e-9+2*(320e-9/ceil(31.9995e-3)):0))/1'
+NRD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:((floor(ceil(31.9995e-3)/2.0)*(110e-9*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?140e-9*(320e-9/ceil(31.9995e-3)):0))/1)/((((320e-9/ceil(31.9995e-3))*ceil(31.9995e-3))*(320e-9/ceil(31.9995e-3)))*ceil(31.9995e-3))' NRS='320e-9/ceil(31.9995e-3)<119.5e-9?(((14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9)+floor((ceil(31.9995e-3)-1)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:(((140e-9*(320e-9/ceil(31.9995e-3))+floor((ceil(31.9995e-3)-1)/2.0)*(110e-9*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?140e-9*(320e-9/ceil(31.9995e-3)):0))/1)/((((320e-9/ceil(31.9995e-3))*ceil(31.9995e-3))*(320e-9/ceil(31.9995e-3)))*ceil(31.9995e-3))' M=1

mpm0 bio_bar bio vdd vdd g45p2svt L=150e-9 W=320e-9 AD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:(floor(ceil(31.9995e-3)/2.0)*(110e-9*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?140e-9*(320e-9/ceil(31.9995e-3)):0))/1' AS='320e-9/ceil(31.9995e-3)<119.5e-9?(((14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9)+floor((ceil(31.9995e-3)-1)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:((140e-9*(320e-9/ceil(31.9995e-3))+floor((ceil(31.9995e-3)-1)/2.0)*(110e-9*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?140e-9*(320e-9/ceil(31.9995e-3)):0))/1'
+PD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*680e-9+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?580e-9:0))/1:(floor(ceil(31.9995e-3)/2.0)*(220e-9+2*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?280e-9+2*(320e-9/ceil(31.9995e-3)):0))/1' PS='320e-9/ceil(31.9995e-3)<119.5e-9?((580e-9+floor((ceil(31.9995e-3)-1)/2.0)*680e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?580e-9:0))/1:(((280e-9+2*(320e-9/ceil(31.9995e-3)))+floor((ceil(31.9995e-3)-1)/2.0)*(220e-9+2*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?280e-9+2*(320e-9/ceil(31.9995e-3)):0))/1'
+NRD='320e-9/ceil(31.9995e-3)<119.5e-9?(floor(ceil(31.9995e-3)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9)+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:((floor(ceil(31.9995e-3)/2.0)*(110e-9*(320e-9/ceil(31.9995e-3)))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)!=0?140e-9*(320e-9/ceil(31.9995e-3)):0))/1)/((((320e-9/ceil(31.9995e-3))*ceil(31.9995e-3))*(320e-9/ceil(31.9995e-3)))*ceil(31.9995e-3))' NRS='320e-9/ceil(31.9995e-3)<119.5e-9?(((14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9)+floor((ceil(31.9995e-3)-1)/2.0)*(14.4e-15+(320e-9/ceil(31.9995e-3))*100e-9))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?14.4e-15+(320e-9/ceil(31.9995e-3))*50e-9:0))/1:(((140e-9*(320e-9/ceil(31.9995e-3))+floor((ceil(31.9995e-3)-1)/2.0)*(110e-9*(320e-9/ceil(31.9995e-3))))+(ceil(31.9995e-3)/2-floor(ceil(31.9995e-3)/2)==0?140e-9*(320e-9/ceil(31.9995e-3)):0))/1)/((((320e-9/ceil(31.9995e-3))*ceil(31.9995e-3))*(320e-9/ceil(31.9995e-3)))*ceil(31.9995e-3))' M=1

***** SMALL OUTPUT LOADS ************************************
Cbio     bio      0  10f
Cbiobar  bio_bar  0  10f

***** TRANSIENT ANALYSIS ************************************
.tran 1p 40n

.probe v(b_core) v(b_core_bar) v(bio) v(bio_bar)

.END
